<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GC010-Bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\GC010-Firmware.ewp</path>
  </project>
  <batchBuild/>
</workspace>


